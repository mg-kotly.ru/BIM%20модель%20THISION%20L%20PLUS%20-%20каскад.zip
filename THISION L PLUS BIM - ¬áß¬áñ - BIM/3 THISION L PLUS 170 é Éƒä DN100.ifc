Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-08-21T08:27:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.1.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 21 08:27:49 2023 * Host: GVIZITI-RO-LE * Database: C:\Users\gviziti\AppData\Local\Temp\4ad8c3a7-5ca9-47c6-a4e9-c62a7f850936\0c00e5b6-e795-4eef-85b2-7014c4dce34f\ifc * Database version: 5507 * Database creation date: Mon Aug 21 08:27:46 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Aug 21 08:27:46 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 21 08:27:46 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcBoiler: HC_Boiler_MEPcontent_Elco_THISION L PLUS 170_INT-EN_Shared:THISION L PLUS 170 (3)
In: F00
Type - PredefinedType: WATER; Material: Color RGB 049-049-049, Color RGB 216-216-216, Color RGB 172-184-196, Color RAL 9016
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Use Nominal Diameter: yes; Depth: 670 mm; Drain Diameter: 32 mm; Flue Gas Diameter: 130 mm; Gas Diameter: 28.6 mm; Height: 1050 mm; Hydronic Return Diameter: 45 mm; Hydronic Supply Diameter: 45 mm; Supply Air Diameter: 130 mm; Width: 690 mm
Type - Electrical - Electrical Connection: 230 V; Frequency: 50 Hz; Hertz: 50 Hz; IP Class: IPX4D; Mains Connection Fuse: 6.3 A; Phase: 1; Power Consumption Boiler max ErP (Incl. Pump): 464 W; Power Consumption Boiler min ErP (Incl. Pump): 109 W; Voltage: 230 V
Type - General - CE Certification Code: 0063CT3449; Maximum Gas Pressure: 5750 Pa; Min Gas Pressure H-gas: 1700 Pa; Min Gas Pressure L-gas: 2000 Pa; Min Gas Pressure LPG (mbar): 25-35; Minimum Heat Input Hi min: 14900 W; Minimum Heat Output at 40/30ºC: 16100 W; Minimum Heat Output at 50/30ºC: 16100 W; Minimum Heat Output at 75-60ºC: 14600 W; Minimum Heat Output at 80-60ºC: 14700 W; Modulation: 11; Noise Level (dB(A)): 67; Nominal Heat Input Hi max: 158800 W; Nominal Heat Output at 40/30ºC: 170900 W; Nominal Heat Output at 50/30ºC: 170400 W; Nominal Heat Output at 75-60ºC: 154400 W; Nominal Heat Output at 80-60ºC: 155500 W; Sound Pressure Level (dB(A)): 56; Weight (empty): 132 kg
Type - Identity Data - Custom: no; Article Description: Boiler 170kW wall hung; Article Type: THISION L PLUS 170; Base Family Version: 23.05; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Description: Boiler 170kW wall hung; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.09; Manufacturer: Elco; Manufacturer URL: http://www.elco.net/; MEPcontent Class: BOILER; Model: THISION L PLUS 170; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: Elco; Revit Version: 2020; Type Name: THISION L PLUS 170; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 049-049-049; Light Grey: Color RGB 172-184-196; Light White: Color RAL 9016; White: Color RGB 216-216-216
Type - Mechanical - Hydraulic Resistance at Nominal Water Flow: 34420 Pa; Hydraulic Resistance at Nominal Water Flow (dT 25K): 22030 Pa; Max. Condensate (full load @ 40/30ºC, 20ºC ambient, G20): 0.00000458333 m3/s; Max. Permissible Flue Resistance max: 215 Pa; Maximum Available Head for System: 8100 Pa; Maximum Temperature Setpoint: 90 kg/K/s3; Maximum Water Temperature (High Limit Thermostat): 95 kg/K/s3; Nominal Power 50-30°C: 0 W; Nominal Power 80-60°C: 0 W; Nominal Water Flow at dT=20K: 0.00188889 m3/s; Nominal Water Flow at dT=25K: 0.0015 m3/s; NOx Class: 6; Tap Capacity at 60°C: 0 m3/s; Total Head at Nominal Flow: 42500 Pa; Volume: 0 m3; Water Pressure max: 600000 Pa; Water Pressure min: 70000 Pa; Water Volume: 0.0213 m3; ΔT max (K): 30
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Elco_THISION L PLUS 170_INT-EN_Shared
Type - Pset_BoilerTypeCommon - Reference: THISION L PLUS 170
Type - Pset_EnvironmentalImpactIndicators - Reference: THISION L PLUS 170
Type - Pset_ManufacturerTypeInformation - Manufacturer: Elco
Material: Color RGB 049-049-049 (4), Color RGB 216-216-216 (10), Color RAL 9016, Color RGB 172-184-196
Pset_BoilerTypeCommon - sets with these values: 2
Constraints - Elevation from Level: 675 mm; Moves With Nearby Elements: no; Offset from Host: 675 mm
Dimensions - Area: 1.97274 m2; Volume: 0.498743 m3
Electrical - Loads - Power: 464 W
Other - Family: HC_Boiler_MEPcontent_Elco_THISION L PLUS 170_INT-EN_Shared: THISION L PLUS 170; Family and Type: HC_Boiler_MEPcontent_Elco_THISION L PLUS 170_INT-EN_Shared: THISION L PLUS 170; Type: HC_Boiler_MEPcontent_Elco_THISION L PLUS 170_INT-EN_Shared: THISION L PLUS 170; Type Id: HC_Boiler_MEPcontent_Elco_THISION L PLUS 170_INT-EN_Shared: THISION L PLUS 170
Phasing - Phase Created: 4. Plan over 10 years
Name (HC_Boiler_MEPcontent_Elco_THISION L PLUS 170_INT-EN_Shared:THISION L PLUS 170:...) | Mark
1329651 | 5
1329652 | 6
1329653 | 7

# IfcBoiler: HC_Boiler_MEPcontent_Elco_THISION L PLUS CASCADE_IN LINE_3 BOILERS_140-170kW_DN 100_INT-EN:IN LINE_3 BOILERS_170kW_DN 100, HC_Boiler_MEPcontent_Elco_THISION L PLUS CASCADE_IN LINE_3 BOILERS_140-170kW_DN 100_INT-EN:IN LINE_3 BOILERS_170kW_DN 100:1329560
In: F00
Type - Material: Color RGB 245-197-044, Color RGB 023-097-171, Color RGB 178-000-000, Color RGB 127-127-127
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 780 mm; Drain Diameter: 32 mm; Flue Gas Diameter: 130 mm; Gas Diameter: 65 mm; Gas Nominal Diameter: 65 mm; Gas Outer Diameter: 76.1 mm; Height: 1700 mm; Hydronic Nominal Diameter: 100 mm; Hydronic Outer Diameter: 114.3 mm; Hydronic Return Diameter: 100 mm; Hydronic Supply Diameter: 100 mm; Supply Air Diameter: 130 mm; Use Nominal Diameter: yes; Width: 2795 mm
Type - Electrical - Electrical Connection: 230 V; Frequency: 50 Hz; IP Class: IPX4D; Mains Connection Fuse: 0 A; Power Consumption Boiler max ErP (Incl. Pump): 464 W; Power Consumption Boiler min ErP (Incl. Pump): 109 W; Voltage: 230 V
Type - General - CE Certification Code: 0063CT3449; Maximum Gas Pressure: 5750 Pa; Min Gas Pressure H-gas: 1700 Pa; Min Gas Pressure L-gas: 2000 Pa; Min Gas Pressure LPG (mbar): 25-35; Minimum Heat Input Hi min: 14900 W; Minimum Heat Output at 40/30ºC: 16100 W; Minimum Heat Output at 50/30ºC: 16000 W; Minimum Heat Output at 75-60ºC: 14600 W; Minimum Heat Output at 80-60ºC: 14600 W; Modulation: 0; Noise Level (dB(A)): 0; Nominal Heat Input Hi max: 476400 W; Nominal Heat Output at 40/30ºC: 512550 W; Nominal Heat Output at 50/30ºC: 511200 W; Nominal Heat Output at 75-60ºC: 479100 W; Nominal Heat Output at 80-60ºC: 466350 W; Sound Pressure Level (dB(A)): 0; Weight (empty): 396 kg
Type - Identity Data - Article Description: Cascade wall hung - 3_3x170 - In Line; Article Type: IN LINE_3 BOILERS_170kW_DN 100; Base Family Version: 23.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Cascade wall hung - 3_3x170 - In Line; EMCS Version: 5.0; ETIM Article Class: EC011755; Family Version: 23.09; Manufacturer: Elco; Manufacturer URL: http://www.elco.net/; MEPcontent Class: BOILER; Model: IN LINE_3 BOILERS_170kW_DN 100; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: Elco; Revit Version: 2021; Type Name: IN LINE_3 BOILERS_170kW_DN 100; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Blue: Color RGB 023-097-171; Grey: Color RGB 127-127-127; Red: Color RGB 178-000-000; Yellow: Color RGB 245-197-044
Type - Mechanical - Hydraulic Resistance at Nominal Water Flow: 34420 Pa; Hydraulic Resistance at Nominal Water Flow (dT 25K): 22030 Pa; Max. Condensate (full load @ 40/30ºC, 20ºC ambient, G20): 0.00001375 m3/s; Max. Permissible Flue Resistance max: 645 Pa; Maximum Temperature Setpoint: 90 kg/K/s3; Maximum Water Temperature (High Limit Thermostat): 95 kg/K/s3; Nominal Power 50-30°C: 0 W; Nominal Power 80-60°C: 0 W; Nominal Water Flow at dT=20K: 0.00558333 m3/s; Nominal Water Flow at dT=25K: 0.00446667 m3/s; NOx Class: 6; Tap Capacity at 60°C: 0 m3/s; Volume: 0 m3; Water Pressure max: 600000 Pa; Water Pressure min: 70000 Pa; Water Volume: 0.0639 m3; ΔT max (K): 30
Type - Other - Category: Mechanical Equipment; Boiler Type: HC_Boiler_MEPcontent_Elco_THISION L PLUS 170_INT-EN_Shared: THISION L PLUS 170; Connectors Position: 246 mm; Distance Boilers: 700 mm; Family Name: HC_Boiler_MEPcontent_Elco_THISION L PLUS CASCADE_IN LINE_3 BOILERS_140-170kW_DN 100_INT-EN; First Ventilation Position: 365 mm; Gas Pipe Depth: 542 mm; Gas Position: 240 mm; Header Depth: 372 mm; Header Length: 665 mm; Hydronic Pipe Depth: 372 mm; Hydronic Return Position: 150 mm; Hydronic Supply Position: 370 mm; Length Boilers: 2130 mm; Number of Boilers: 3; Number of Poles: 4; Ventilation Connectors Depth: 243 mm
Type - Pset_BoilerTypeCommon - Reference: IN LINE_3 BOILERS_170kW_DN 100
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 4
Type - Pset_EnvironmentalImpactIndicators - Reference: IN LINE_3 BOILERS_170kW_DN 100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Elco
Material: Color RGB 245-197-044 (6), Color RGB 023-097-171 (10), Color RGB 178-000-000 (10), Color RGB 127-127-127 (16)
Pset_BoilerTypeCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 5.86393 m2; Volume: 0.43333 m3
Electrical - Loads - Power: 464 W
Identity Data - Mark: 4
Mechanical - System Classification: Hydronic Supply,Hydronic Return,Hydronic Supply,Hydronic Return,Other,Sanitary,Power,Supply Air,Other,Sanitary
Mechanical - Flow - Drain Fixture Units 1: 0; Drain Fixture Units 2: 0; Drain Fixture Units 3: 0; Flue Gas Flow 1: 0 m3/s; Flue Gas Flow 2: 0 m3/s; Flue Gas Flow 3: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow 1: 0 m3/s; Supply Air Flow 2: 0 m3/s; Supply Air Flow 3: 0 m3/s
Other - Counter Flange Left: no; Counter Flange Right: no; Family: HC_Boiler_MEPcontent_Elco_THISION L PLUS CASCADE_IN LINE_3 BOILERS_140-170kW_DN 100_INT-EN: IN LINE_3 BOILERS_170kW_DN 100; Family and Type: HC_Boiler_MEPcontent_Elco_THISION L PLUS CASCADE_IN LINE_3 BOILERS_140-170kW_DN 100_INT-EN: IN LINE_3 BOILERS_170kW_DN 100; Gas Pipe Length: 2100 mm; Header Position Left Safe: 0 mm; Header Position Right Safe: 750 mm; Left Hydronic Return: 195 mm; Left Hydronic Supply: 755 mm; Reference Line Length Left: 1730 mm; Reference Line Length Right: 1050 mm; Right Hydronic Return: 150 mm; Right Hydronic Supply: 370 mm; Type: HC_Boiler_MEPcontent_Elco_THISION L PLUS CASCADE_IN LINE_3 BOILERS_140-170kW_DN 100_INT-EN: IN LINE_3 BOILERS_170kW_DN 100; Type Id: HC_Boiler_MEPcontent_Elco_THISION L PLUS CASCADE_IN LINE_3 BOILERS_140-170kW_DN 100_INT-EN: IN LINE_3 BOILERS_170kW_DN 100
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Counter Flange: no; Header Position Left: yes; Header Position Right: no

# IfcDistributionPort (18)
Description: Flow
Name | FlowDirection
9 x Port_1329560 | SOURCEANDSINK
6 x Port_1329560 | SINK
3 x Port_1329560 | SOURCE
